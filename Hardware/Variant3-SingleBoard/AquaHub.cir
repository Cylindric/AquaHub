.title KiCad schematic
J8 NEUTRAL EARTH /LIVE_IN Screw_Terminal_01x03
U1 GND +3V3 Net-_R4-Pad1_ NC_01 NC_02 POW1 POW2 POW3 POW4 POW5 POW6 POWER_SENSE NC_03 NC_04 GND NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 RX TX NC_23 FLOW_SENSE GND NC_24 ESP32-WROVER-I
U2 LIVE LIVE /LIVE_IN /LIVE_IN GND Net-_R1-Pad2_ POWER_SENSE +5V ACS723
C2 POWER_SENSE GND 1nF
C1 +5V GND 0.1uF
R1 +5V Net-_R1-Pad2_ 4.7K
J2 LIVE2 EARTH NEUTRAL2 Screw_Terminal
J10 GND RX TX +5V ISP
J9 GND Net-_J9-Pad2_ +5V FLOW
R2 FLOW_SENSE Net-_J9-Pad2_ 2.2K
R3 GND FLOW_SENSE 3.3K
V1 NEUTRAL LIVE GND +12V RAC01-12SGB
MH2 MountingHole
MH1 MountingHole
MH3 MountingHole
MH4 MountingHole
J7 NEUTRAL EARTH LIVE Screw_Terminal
U4 POW1 POW2 POW3 POW4 POW5 POW6 NC_25 GND +12V NC_26 RE6 RE5 RE4 RE3 RE2 RE1 TPL7407LA
U5 +12V GND +5V 5V Reg
U3 +12V GND +3V3 3.3V Reg
K1 RE1 NEUTRAL NC_27 NEUTRAL1 LIVE1 NC_28 LIVE +12V MT2-C93402
J4 LIVE4 EARTH NEUTRAL4 Screw_Terminal
J6 LIVE6 EARTH NEUTRAL6 Screw_Terminal
J1 LIVE1 EARTH NEUTRAL1 Screw_Terminal
J3 LIVE3 EARTH NEUTRAL3 Screw_Terminal
J5 LIVE5 EARTH NEUTRAL5 Screw_Terminal
K2 RE2 NEUTRAL NC_29 NEUTRAL2 LIVE2 NC_30 LIVE +12V MT2-C93402
K3 RE3 NEUTRAL NC_31 NEUTRAL3 LIVE3 NC_32 LIVE +12V MT2-C93402
K4 RE4 NEUTRAL NC_33 NEUTRAL4 LIVE4 NC_34 LIVE +12V MT2-C93402
K5 RE5 NEUTRAL NC_35 NEUTRAL5 LIVE5 NC_36 LIVE +12V MT2-C93402
K6 RE6 NEUTRAL NC_37 NEUTRAL6 LIVE6 NC_38 LIVE +12V MT2-C93402
C3 +3V3 GND 10uF
C4 +3V3 GND 100uF
R4 Net-_R4-Pad1_ +3V3 10k
RV1 LIVE NEUTRAL S14MOV
.end
